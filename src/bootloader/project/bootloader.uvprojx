# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\libs\std;..\libs\usb;..\users\usb_hid;..\users\system\cmsis;..\users\system\startup;..\users\system;..\users\periph;..\users\drivers;..\users\services;..\users\controls;..\users\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group std_lib
    ../libs/std/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group usb_lib
    ../libs/usb/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usb_hid
    ../users/usb_hid/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group system
    ../users/system/cmsis/: core_cm3.c system_stm32f10x.c
    ../users/system/startup/: startup_stm32f10x_hd.s
    ../users/system/: stm32_it.c main.c boot_loader.c common.c system.c task.c
  group services
    ../users/services/: time_server.c
  group controls
    ../users/controls/: server_comm_control.c server_comm_protocol.c
software components: CMSIS:CORE 4.3.0
